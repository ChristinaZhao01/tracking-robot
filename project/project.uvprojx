# Keil uVision project project.uvprojx, settings and files
target project (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\user;..\lib\STM32F10x_StdPeriph_Driver\inc;..\lib\CMSIS\CM3\CoreSupport;..\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group user
    ../user/: main.c timer.c calculate.c stepmotor.c st188.c filter.c usart.c mpu6050.c stm32f10x_it.c iic.c
  group lib
    ../lib/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_i2c.c misc.c stm32f10x_spi.c
  group cmsis
    ../lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group start_up
    ../lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group readme
    ../: 打开工程前先读我.txt
software components: CMSIS:CORE 5.0.1
